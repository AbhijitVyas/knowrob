Commit message: avatar yasmin and kitchen clash

File: urdf/avatar_yasmin_0.urdf (robot description, URDF)
Before this commit: robot avatar_yasmin, 95 links, 94 joints
Links:
- link root: geometry 
